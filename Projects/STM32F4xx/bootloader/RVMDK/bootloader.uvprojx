# Keil uVision project bootloader.uvprojx, settings and files
target MiCOKit-3288 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG HSE_VALUE=16000000 BOOTLOADER NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\MICO\system;..\..\..\..\MICO\security;..\..\..\..\libraries\utilities;..\..\..\..\Board\MiCOKit-3288;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M4;..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\Platform\Drivers\MiCOKit_EXT
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Board/MiCOKit-3288
    ../../../../Board/MiCOKit-3288/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3165
    ../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Include
    ../../../../include/: MICO.h
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h
  group Platform/Drivers/MiCOKit-EXT/sensors
    ../../../../Platform/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c
    ../../../../Platform/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c
    ../../../../Platform/Drivers/MiCOKit_EXT/key/: keys.c
    ../../../../Platform/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c oled.c
    ../../../../Platform/Drivers/MiCOKit_EXT/light/: light_sensor.c
    ../../../../Platform/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c rgb_led.c
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280_user.c
  group Platform/Drivers/SPI_Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/RVMDK
    ../../../../Platform/MCU/STM32F4xx/RVMDK/: startup_stm32f4xx_bootloader_RVMDK.s
  group Platform/MCU/STM32F4xx/wlan_bus_driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Platform/MCU/STM32F4xx/peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/MCU/STM32F4xx/peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group libraries\utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
target MiCOKit-3165 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: as above
  output: Bootloader.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER HSE_VALUE=26000000 BOOTLOADER NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\MICO\system;..\..\..\..\libraries\utilities;..\..\..\..\MICO\security;..\..\..\..\Board\MiCOKit-3165;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M4;..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\Platform\Drivers\MiCOKit_EXT
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
