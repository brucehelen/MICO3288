# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-G55 (ARM)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel ATSAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG55J19__; ARM_MATH_CM4=true; BOARD=USER_BOARD; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MiCOKit-G55; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\ioport; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include\instance; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\preprocessor; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\header_files; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\boards; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-G55\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board/MiCOKit-G55
    ../../../../Board/MiCOKit-G55/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c MicoDefaults.h Update_for_OTA.c ymodem.c
  group include
    ../../../../include/: mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../Platform/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../Platform/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../Platform/Drivers/MiCOKit_EXT/key/: keys.c keys.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../Platform/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../Platform/Drivers/MiCOKit_EXT/light/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../Platform/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STSAMG55
    ../../../../Platform/MCU/ATSAMG55/: platform_init.c
  group Platform/MCU/STSAMG55/EWARM
    ../../../../Platform/MCU/ATSAMG55/EWARM/: startup_ATSAMG55_bootloader_EWARM.s
  group Platform/MCU/STSAMG55/Peripherals
    ../../../../Platform/MCU/ATSAMG55/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/clock
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/clock/samg/: sysclk.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/sleepmgr
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/sleepmgr/sam/: sleepmgr.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/utils/interrupt
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/adc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/adc/: adc2.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/efc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/efc/: efc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom/: flexcom.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pdc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pdc/: pdc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pio
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pio/: pio.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pmc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pmc/: pmc.c sleep.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/spi
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/spi/: spi.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/twi
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/twi/: twi.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/usart
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/usart/: usart.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/wdt
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/wdt/: wdt.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/services/flash_efc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/services/flash_efc/: flash_efc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/utils/cmsis
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
