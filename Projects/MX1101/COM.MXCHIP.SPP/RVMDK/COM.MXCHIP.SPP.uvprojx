# Keil uVision project COM.MXCHIP.SPP.uvprojx, settings and files
target MicoKit-3088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\MiCOKit-3088\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\MiCOKit-3088\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\Board\MicoKit-3088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\mico\system;..\..\..\..\libraries\utilities
  memory RVCT4: ROM 0xb000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238,L6436W,L6432W,L6433W --no_strict_wchar_size  --no_strict_enum_size
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group mico/core
    ../../../../mico/core/: ChangeLog_8801.txt ChangeLog_43362.txt mico_config.c mxchipWNet_cm3_8801.a mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
    ../../../../mico/core/RF driver/: wlan_firmware.c
  group mico/system
    ../../../../mico/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
    ../../../../mico/system/command_console/: mico_cli.c
    ../../../../mico/system/config_server/: config_server.c config_server_menu.c
    ../../../../mico/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
    ../../../../mico/system/mdns/: mico_mdns.c
    ../../../../mico/system/tftp_ota/: tftp_ota.c tftpc.o
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/MX1101
    ../../../../Platform/MCU/MX1101/: platform_init.c
  group Platform/MCU/MX1101/RVMDK
    ../../../../Platform/MCU/MX1101/RVMDK/: startup_mx1101.s
  group Platform/MCU/MX1101/wlan_bus_driver
    ../../../../Platform/MCU/MX1101/wlan_bus_driver/: wlan_bus_sdio.c
  group Platform/MCU/MX1101/peripherals
    ../../../../Platform/MCU/MX1101/peripherals/: platform_mcu_powersave.c platform_gpio.c platform_flash.c platform_uart.c platform_adc.c platform_i2c.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_spi_slave.c platform_watchdog.c platform_nano_second.c
  group Platform/MCU/MX1101/peripherals/Libraries
    ../../../../Platform/MCU/MX1101/peripherals/Libraries/: driver.lib
  group Board/MicoKit-3088
    ../../../../Board/MiCOKit-3088/: platform.c platform.h platform_config.h
  group Board/EMW5088
    ../../../../Board/EMW5088/: platform.c platform.h platform_config.h
target EMW5088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\EMW5088\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\EMW5088\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\Board\EMW5088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\mico\system;..\..\..\..\libraries\utilities
  memory RVCT4: ROM 0xb000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: as above
